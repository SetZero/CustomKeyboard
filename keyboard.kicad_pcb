File: keyboard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 350.9 x 122.3 mm, 182 parts

Commit message: Update Layout + Add CubeMX file
Other:
- net class Default removed
